Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Acoustics_Akustikmiljo_TILES-ECOSUND-GRID-CEILING-ABSORBENT.ifc
Time: 2020-05-14T15:15:49
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: TILES ECOSUND GRID CEILING ABSORBENT
ePset_BIMobjectScript - Size: 593_593_20 mm; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): TILES ECOSUND GRID CEILING ABSORBENT; SKU (BO_prodsku): TILES-ECOSUND-GRID-CEILING-ABSORBENT; ManufacturName (BO_Manufac): Akustikmiljö; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/akustikmiljo/product/TILES-ECOSUND-GRID-CEILING-ABSORBENT; ProductDataUrl (BO_prodaturl): bimobject.com/akustikmiljo/product/TILES-ECOSUND-GRID-CEILING-ABSORBENT; ProductUrl (BO_producturl): https://www.amacoustics.com/products/tiles-ecosund-grid-ceiling-absorbent; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Acoustics; BimObjectCategoryCode (BO_bocat_code): furniture-acoustics; IfcClassification (BO_ifcclas): Furniture; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
